<?xml version="1.0" encoding="iso-8859-1"?>

<project>
  <fileVersion>2</fileVersion>
  <configuration>
    <name>Debug</name>
    <toolchain>
      <name>ARM</name>
    </toolchain>
    <debug>1</debug>
    <settings>
      <name>RuntimeChecking</name>
      <archiveVersion>0</archiveVersion>
      <data>
        <version>2</version>
        <wantNonLocal>1</wantNonLocal>
        <debug>1</debug>
        <option>
          <name>GenRtcDebugHeap</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcEnableBoundsChecking</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcCheckPtrsNonInstrMem</name>
          <state>1</state>
        </option>
        <option>
          <name>GenRtcTrackPointerBounds</name>
          <state>1</state>
        </option>
        <option>
          <name>GenRtcCheckAccesses</name>
          <state>1</state>
        </option>
        <option>
          <name>GenRtcGenerateEntries</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcNrTrackedPointers</name>
          <state>1000</state>
        </option>
        <option>
          <name>GenRtcIntOverflow</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcIncUnsigned</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcIntConversion</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcInclExplicit</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcIntShiftOverflow</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcInclUnsignedShiftOverflow</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcUnhandledCase</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcDivByZero</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcEnable</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcCheckPtrsNonInstrFunc</name>
          <state>1</state>
        </option>
      </data>
    </settings>
  </configuration>
  <configuration>
    <name>Release</name>
    <toolchain>
      <name>ARM</name>
    </toolchain>
    <debug>0</debug>
    <settings>
      <name>RuntimeChecking</name>
      <archiveVersion>0</archiveVersion>
      <data>
        <version>2</version>
        <wantNonLocal>1</wantNonLocal>
        <debug>0</debug>
        <option>
          <name>GenRtcDebugHeap</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcEnableBoundsChecking</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcCheckPtrsNonInstrMem</name>
          <state>1</state>
        </option>
        <option>
          <name>GenRtcTrackPointerBounds</name>
          <state>1</state>
        </option>
        <option>
          <name>GenRtcCheckAccesses</name>
          <state>1</state>
        </option>
        <option>
          <name>GenRtcGenerateEntries</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcNrTrackedPointers</name>
          <state>1000</state>
        </option>
        <option>
          <name>GenRtcIntOverflow</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcIncUnsigned</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcIntConversion</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcInclExplicit</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcIntShiftOverflow</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcInclUnsignedShiftOverflow</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcUnhandledCase</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcDivByZero</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcEnable</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcCheckPtrsNonInstrFunc</name>
          <state>1</state>
        </option>
      </data>
    </settings>
  </configuration>
  <configuration>
    <name>CHL_ZC_DEBUG</name>
    <toolchain>
      <name>ARM</name>
    </toolchain>
    <debug>1</debug>
    <settings>
      <name>RuntimeChecking</name>
      <archiveVersion>0</archiveVersion>
      <data>
        <version>2</version>
        <wantNonLocal>1</wantNonLocal>
        <debug>1</debug>
        <option>
          <name>GenRtcDebugHeap</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcEnableBoundsChecking</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcCheckPtrsNonInstrMem</name>
          <state>1</state>
        </option>
        <option>
          <name>GenRtcTrackPointerBounds</name>
          <state>1</state>
        </option>
        <option>
          <name>GenRtcCheckAccesses</name>
          <state>1</state>
        </option>
        <option>
          <name>GenRtcGenerateEntries</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcNrTrackedPointers</name>
          <state>1000</state>
        </option>
        <option>
          <name>GenRtcIntOverflow</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcIncUnsigned</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcIntConversion</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcInclExplicit</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcIntShiftOverflow</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcInclUnsignedShiftOverflow</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcUnhandledCase</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcDivByZero</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcEnable</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcCheckPtrsNonInstrFunc</name>
          <state>1</state>
        </option>
      </data>
    </settings>
  </configuration>
  <configuration>
    <name>CHL_ZR_DEBUG</name>
    <toolchain>
      <name>ARM</name>
    </toolchain>
    <debug>1</debug>
    <settings>
      <name>RuntimeChecking</name>
      <archiveVersion>0</archiveVersion>
      <data>
        <version>2</version>
        <wantNonLocal>1</wantNonLocal>
        <debug>1</debug>
        <option>
          <name>GenRtcDebugHeap</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcEnableBoundsChecking</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcCheckPtrsNonInstrMem</name>
          <state>1</state>
        </option>
        <option>
          <name>GenRtcTrackPointerBounds</name>
          <state>1</state>
        </option>
        <option>
          <name>GenRtcCheckAccesses</name>
          <state>1</state>
        </option>
        <option>
          <name>GenRtcGenerateEntries</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcNrTrackedPointers</name>
          <state>1000</state>
        </option>
        <option>
          <name>GenRtcIntOverflow</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcIncUnsigned</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcIntConversion</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcInclExplicit</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcIntShiftOverflow</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcInclUnsignedShiftOverflow</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcUnhandledCase</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcDivByZero</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcEnable</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcCheckPtrsNonInstrFunc</name>
          <state>1</state>
        </option>
      </data>
    </settings>
  </configuration>
  <configuration>
    <name>CHL_ZE_DEBUG</name>
    <toolchain>
      <name>ARM</name>
    </toolchain>
    <debug>1</debug>
    <settings>
      <name>RuntimeChecking</name>
      <archiveVersion>0</archiveVersion>
      <data>
        <version>2</version>
        <wantNonLocal>1</wantNonLocal>
        <debug>1</debug>
        <option>
          <name>GenRtcDebugHeap</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcEnableBoundsChecking</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcCheckPtrsNonInstrMem</name>
          <state>1</state>
        </option>
        <option>
          <name>GenRtcTrackPointerBounds</name>
          <state>1</state>
        </option>
        <option>
          <name>GenRtcCheckAccesses</name>
          <state>1</state>
        </option>
        <option>
          <name>GenRtcGenerateEntries</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcNrTrackedPointers</name>
          <state>1000</state>
        </option>
        <option>
          <name>GenRtcIntOverflow</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcIncUnsigned</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcIntConversion</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcInclExplicit</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcIntShiftOverflow</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcInclUnsignedShiftOverflow</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcUnhandledCase</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcDivByZero</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcEnable</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcCheckPtrsNonInstrFunc</name>
          <state>1</state>
        </option>
      </data>
    </settings>
  </configuration>
  <group>
    <name>aps</name>
    <file>
      <name>$PROJ_DIR$\ZBOSS_v1.0_src\aps\aps_bind.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\ZBOSS_v1.0_src\aps\aps_commands.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\ZBOSS_v1.0_src\aps\aps_dups.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\ZBOSS_v1.0_src\aps\aps_main.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\ZBOSS_v1.0_src\aps\aps_nwk_confirm.c</name>
    </file>
  </group>
  <group>
    <name>common</name>
    <file>
      <name>$PROJ_DIR$\ZBOSS_v1.0_src\common\zb_address.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\ZBOSS_v1.0_src\common\zb_bufpool.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\ZBOSS_v1.0_src\common\zb_bufpool_init.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\ZBOSS_v1.0_src\common\zb_debug.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\ZBOSS_v1.0_src\common\zb_ib.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\ZBOSS_v1.0_src\common\zb_init.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\ZBOSS_v1.0_src\common\zb_random.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\ZBOSS_v1.0_src\common\zb_scheduler.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\ZBOSS_v1.0_src\common\zb_scheduler_init.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\ZBOSS_v1.0_src\common\zb_time.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\ZBOSS_v1.0_src\common\zb_trace.c</name>
    </file>
  </group>
  <group>
    <name>mac</name>
    <file>
      <name>$PROJ_DIR$\ZBOSS_v1.0_src\mac\mac.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\ZBOSS_v1.0_src\mac\mac_associate.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\ZBOSS_v1.0_src\mac\mac_common.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\ZBOSS_v1.0_src\mac\mac_cr_associate.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\ZBOSS_v1.0_src\mac\mac_cr_coordinator.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\ZBOSS_v1.0_src\mac\mac_cr_data.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\ZBOSS_v1.0_src\mac\mac_data.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\ZBOSS_v1.0_src\mac\mac_disturber.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\ZBOSS_v1.0_src\mac\mac_fcs.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\ZBOSS_v1.0_src\mac\mac_routines.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\ZBOSS_v1.0_src\mac\mac_scan.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\ZBOSS_v1.0_src\mac\zb_cc25xx.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\ZBOSS_v1.0_src\mac\zb_cc25xx_common.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\ZBOSS_v1.0_src\mac\zb_ns3.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\ZBOSS_v1.0_src\mac\zb_uz2400.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\ZBOSS_v1.0_src\mac\zb_uz2410.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\ZBOSS_v1.0_src\mac\zb_uz2x_common.c</name>
    </file>
  </group>
  <group>
    <name>nwk</name>
    <file>
      <name>$PROJ_DIR$\ZBOSS_v1.0_src\nwk\nwk_address_assign.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\ZBOSS_v1.0_src\nwk\nwk_cr_formation.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\ZBOSS_v1.0_src\nwk\nwk_cr_join.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\ZBOSS_v1.0_src\nwk\nwk_cr_mesh_routing.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\ZBOSS_v1.0_src\nwk\nwk_cr_permit_join.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\ZBOSS_v1.0_src\nwk\nwk_cr_route_discovery.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\ZBOSS_v1.0_src\nwk\nwk_cr_tree_routing.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\ZBOSS_v1.0_src\nwk\nwk_discovery.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\ZBOSS_v1.0_src\nwk\nwk_formation.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\ZBOSS_v1.0_src\nwk\nwk_join.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\ZBOSS_v1.0_src\nwk\nwk_main.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\ZBOSS_v1.0_src\nwk\nwk_neighbor.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\ZBOSS_v1.0_src\nwk\nwk_nlme.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\ZBOSS_v1.0_src\nwk\nwk_panid_conflict.c</name>
    </file>
  </group>
  <group>
    <name>osif</name>
  </group>
  <group>
    <name>secur</name>
    <file>
      <name>$PROJ_DIR$\ZBOSS_v1.0_src\secur\aps_secur.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\ZBOSS_v1.0_src\secur\apsme_secur.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\ZBOSS_v1.0_src\secur\mac_secur.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\ZBOSS_v1.0_src\secur\nwk_secur.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\ZBOSS_v1.0_src\secur\secur_ccm.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\ZBOSS_v1.0_src\secur\zb_TI_cc25xx_secur_ccm.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\ZBOSS_v1.0_src\secur\zdo_secur.c</name>
    </file>
  </group>
  <group>
    <name>tests</name>
    <group>
      <name>zdo_startup</name>
      <file>
        <name>$PROJ_DIR$\ZBOSS_v1.0_src\tests\zdo_startup\zdo_start_zc.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\ZBOSS_v1.0_src\tests\zdo_startup\zdo_start_ze.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\ZBOSS_v1.0_src\tests\zdo_startup\zdo_start_zr.c</name>
      </file>
    </group>
  </group>
  <group>
    <name>zdo</name>
    <file>
      <name>$PROJ_DIR$\ZBOSS_v1.0_src\zdo\af_descriptor.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\ZBOSS_v1.0_src\zdo\af_rx.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\ZBOSS_v1.0_src\zdo\test_profile.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\ZBOSS_v1.0_src\zdo\zdo_app.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\ZBOSS_v1.0_src\zdo\zdo_bind_manage.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\ZBOSS_v1.0_src\zdo\zdo_channel_manager.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\ZBOSS_v1.0_src\zdo\zdo_common.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\ZBOSS_v1.0_src\zdo\zdo_disc_cli.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\ZBOSS_v1.0_src\zdo\zdo_disc_srv.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\ZBOSS_v1.0_src\zdo\zdo_nwk_manage_cli.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\ZBOSS_v1.0_src\zdo\zdo_nwk_manage_srv.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\ZBOSS_v1.0_src\zdo\zdo_rx.c</name>
    </file>
  </group>
</project>


