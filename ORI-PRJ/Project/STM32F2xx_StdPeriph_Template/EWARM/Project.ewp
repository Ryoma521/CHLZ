# IAR project Project.ewp, settings and files
configuration SI4463-RX (ARM, debug)
  General.OGChipSelectEditMenu: STM32F205RG ST STM32F205RG
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  ICCARM.CCDefines: USE_STDPERIPH_DRIVER; STM32F2XX; USE_STM322xG_EVAL; SI4463RX; UART_LOGGING_SUPPORT
  ICCARM.CCIncludePath2: ..\; ..\..\..\Libraries\CMSIS\CM3\CoreSupport; ..\..\..\Libraries\CMSIS\CM3\DeviceSupport\ST\STM32F2xx; ..\..\..\Utilities\STM32_EVAL; ..\..\..\Utilities\STM32_EVAL\Common; ..\..\..\Utilities\STM32_EVAL\STM322xG_EVAL; ..\..\..\Libraries\STM32F2xx_StdPeriph_Driver\inc; ..\..\..\Project\STM32F2xx_StdPeriph_Template\cc1120; ..\..\..\Project\STM32F2xx_StdPeriph_Template\Debug; ..\..\..\Project\STM32F2xx_StdPeriph_Template\kernel; ..\..\..\Project\STM32F2xx_StdPeriph_Template\cc1190; ..\..\..\Project\STM32F2xx_StdPeriph_Template\switch; ..\..\..\Project\STM32F2xx_StdPeriph_Template\SI4463
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: Project.srec
  ILINK.IlinkOutputFile: Project.out
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration SI4463-TX (ARM, debug)
  as the first configuration, except:
  ICCARM.CCDefines: USE_STDPERIPH_DRIVER; STM32F2XX; USE_STM322xG_EVAL; SI4463TX
configuration NODE (ARM, debug)
  as the first configuration, except:
  ICCARM.CCDefines: USE_STDPERIPH_DRIVER; STM32F2XX; USE_STM322xG_EVAL; NODE; ZB_PLATFORM_8051_SIM; ZB_SI44XX; xZB_CC25XX; ZB_IAR; xZB_SECURITY; xZB_ED_ROLE; xZB_TRACE_LEVEL=2; xZB_TRAFFIC_DUMP_ON
  ICCARM.CCIncludePath2: ..\; ..\..\..\Libraries\CMSIS\CM3\CoreSupport; ..\..\..\Libraries\CMSIS\CM3\DeviceSupport\ST\STM32F2xx; ..\..\..\Utilities\STM32_EVAL; ..\..\..\Utilities\STM32_EVAL\Common; ..\..\..\Utilities\STM32_EVAL\STM322xG_EVAL; ..\..\..\Libraries\STM32F2xx_StdPeriph_Driver\inc; ..\..\..\Project\STM32F2xx_StdPeriph_Template\Debug; ..\..\..\Project\STM32F2xx_StdPeriph_Template\kernel; ..\..\..\Project\STM32F2xx_StdPeriph_Template\switch; ..\..\..\Project\STM32F2xx_StdPeriph_Template\SI4463; ..\..\..\Project\STM32F2xx_StdPeriph_Template\ZB\include; ..\..\..\Project\STM32F2xx_StdPeriph_Template\ZB\osif\include; ..\..\..\Project\STM32F2xx_StdPeriph_Template\ZB\mac\si44xx
configuration NODE-ZC (ARM, debug)
  as the first configuration, except:
  ICCARM.CCDefines: as above
  ICCARM.CCIncludePath2: as above
configuration NODE-ZE (ARM, debug)
  as the first configuration, except:
  ICCARM.CCDefines: USE_STDPERIPH_DRIVER; STM32F2XX; USE_STM322xG_EVAL; NODE; ZB_PLATFORM_8051_SIM; ZB_SI44XX; xZB_CC25XX; ZB_IAR; xZB_SECURITY; ZB_ED_ROLE; xZB_TRACE_LEVEL=2; xZB_TRAFFIC_DUMP_ON
  ICCARM.CCIncludePath2: as above
configuration NODE-ZR (ARM, debug)
  as the first configuration, except:
  ICCARM.CCDefines: as above
  ICCARM.CCIncludePath2: as above
  group CMSIS
    ../../../Libraries/CMSIS/CM3/CoreSupport/: core_cm3.c
    ../: system_stm32f2xx.c
  group Debug
    ../Debug/: Debug.c Debug.h
  group EWARM
    ../../../Libraries/CMSIS/CM3/DeviceSupport/ST/STM32F2xx/startup/iar/: startup_stm32f2xx.s
  group Kernel
    ../Kernel/: Hal_drivers.c Hal_drivers.h Hal_mcu.h Hal_timer.c Hal_timer.h hal_types.h Kernel.c Kernel.h Kernel_Memory.c Kernel_Memory.h Kernel_Tasks.h Kernel_Timers.c Kernel_Timers.h OnBoard.h ZComDef.h
  group SI4463
    ../SI4463/: radio.c radio_comm.c radio_config.h radio_config_1st.h radio_config_2nd.h radio_hal.c radio_mcu.c si4463.c si4463_spi.c
  group STM32_EVAL
    ../../../Utilities/STM32_EVAL/STM322xG_EVAL/: stm322xg_eval_fsmc_sram.c stm322xg_eval_ioe.c stm322xg_eval_lcd.c
    ../../../Utilities/STM32_EVAL/: stm32_eval.c
  group STM32F2xx_StdPeriph_Driver
    ../../../Libraries/STM32F2xx_StdPeriph_Driver/src/: misc.c stm32f2xx_adc.c stm32f2xx_can.c stm32f2xx_crc.c stm32f2xx_cryp.c stm32f2xx_cryp_aes.c stm32f2xx_cryp_des.c stm32f2xx_cryp_tdes.c stm32f2xx_dac.c stm32f2xx_dbgmcu.c stm32f2xx_dcmi.c stm32f2xx_dma.c stm32f2xx_exti.c stm32f2xx_flash.c stm32f2xx_fsmc.c stm32f2xx_gpio.c stm32f2xx_hash.c stm32f2xx_hash_md5.c stm32f2xx_hash_sha1.c stm32f2xx_i2c.c stm32f2xx_iwdg.c stm32f2xx_pwr.c stm32f2xx_rcc.c stm32f2xx_rng.c stm32f2xx_rtc.c stm32f2xx_sdio.c stm32f2xx_spi.c stm32f2xx_syscfg.c stm32f2xx_tim.c stm32f2xx_usart.c stm32f2xx_wwdg.c
  group switch
    ../switch/: SWITCH.c switch.h
  group User
    ../: common.c main.c node.c stm32f2xx_it.c uart.c
  group ZB/aps
    ../ZB/aps/: aps_bind.c aps_commands.c aps_dups.c aps_main.c aps_nwk_confirm.c
  group ZB/common
    ../ZB/common/: zb_address.c zb_bufpool.c zb_bufpool_init.c zb_debug.c zb_ib.c zb_init.c zb_random.c zb_scheduler.c zb_scheduler_init.c zb_time.c zb_trace.c
  group ZB/mac
    ../ZB/mac/: mac.c mac_associate.c mac_common.c mac_cr_associate.c mac_cr_coordinator.c mac_cr_data.c mac_data.c mac_disturber.c mac_fcs.c mac_routines.c mac_scan.c zb_cc25xx.c zb_cc25xx_common.c zb_ns3.c zb_si44xx.c zb_si44xx_common.c zb_uz2400.c zb_uz2410.c zb_uz2x_common.c
  group ZB/nwk
    ../ZB/nwk/: nwk_address_assign.c nwk_cr_formation.c nwk_cr_join.c nwk_cr_mesh_routing.c nwk_cr_permit_join.c nwk_cr_route_discovery.c nwk_cr_tree_routing.c nwk_discovery.c nwk_formation.c nwk_join.c nwk_main.c nwk_neighbor.c nwk_nlme.c nwk_panid_conflict.c
  group ZB/osif/8051
    ../ZB/osif/8051/: zb_8051_dummy.c zb_8051_nvram.c zb_8051_serial.c zb_8051_serial_init.c zb_8051_spi.c zb_8051_spi_init.c zb_8051_xram.c zb_mac_transport_8051_direct.c zb_mac_transport_8051_ser.c zb_mac_transport_8051_spi.c zb_sysinit.c zb_time_8051.c zb_time_8051_init.c zb_trace_8051.c zb_uz2400_common.c
  group ZB/secur
    ../ZB/secur/: aps_secur.c apsme_secur.c mac_secur.c nwk_secur.c secur_ccm.c zb_TI_cc25xx_secur_ccm.c zdo_secur.c
  group ZB/tests/zdo_startup
    ../ZB/tests/zdo_startup/: zdo_start_zc.c zdo_start_ze.c zdo_start_zr.c
  group ZB/zdo
    ../ZB/zdo/: af_descriptor.c af_rx.c test_profile.c zdo_app.c zdo_bind_manage.c zdo_channel_manager.c zdo_common.c zdo_disc_cli.c zdo_disc_srv.c zdo_nwk_manage_cli.c zdo_nwk_manage_srv.c zdo_rx.c
