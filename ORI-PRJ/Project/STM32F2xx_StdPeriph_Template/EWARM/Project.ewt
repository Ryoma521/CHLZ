<?xml version="1.0" encoding="iso-8859-1"?>

<project>
  <fileVersion>2</fileVersion>
  <configuration>
    <name>SI4463-RX</name>
    <toolchain>
      <name>ARM</name>
    </toolchain>
    <debug>1</debug>
    <settings>
      <name>RuntimeChecking</name>
      <archiveVersion>0</archiveVersion>
      <data>
        <version>2</version>
        <wantNonLocal>1</wantNonLocal>
        <debug>1</debug>
        <option>
          <name>GenRtcDebugHeap</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcEnableBoundsChecking</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcCheckPtrsNonInstrMem</name>
          <state>1</state>
        </option>
        <option>
          <name>GenRtcTrackPointerBounds</name>
          <state>1</state>
        </option>
        <option>
          <name>GenRtcCheckAccesses</name>
          <state>1</state>
        </option>
        <option>
          <name>GenRtcGenerateEntries</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcNrTrackedPointers</name>
          <state>1000</state>
        </option>
        <option>
          <name>GenRtcIntOverflow</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcIncUnsigned</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcIntConversion</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcInclExplicit</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcIntShiftOverflow</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcInclUnsignedShiftOverflow</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcUnhandledCase</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcDivByZero</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcEnable</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcCheckPtrsNonInstrFunc</name>
          <state>1</state>
        </option>
      </data>
    </settings>
  </configuration>
  <configuration>
    <name>SI4463-TX</name>
    <toolchain>
      <name>ARM</name>
    </toolchain>
    <debug>1</debug>
    <settings>
      <name>RuntimeChecking</name>
      <archiveVersion>0</archiveVersion>
      <data>
        <version>2</version>
        <wantNonLocal>1</wantNonLocal>
        <debug>1</debug>
        <option>
          <name>GenRtcDebugHeap</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcEnableBoundsChecking</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcCheckPtrsNonInstrMem</name>
          <state>1</state>
        </option>
        <option>
          <name>GenRtcTrackPointerBounds</name>
          <state>1</state>
        </option>
        <option>
          <name>GenRtcCheckAccesses</name>
          <state>1</state>
        </option>
        <option>
          <name>GenRtcGenerateEntries</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcNrTrackedPointers</name>
          <state>1000</state>
        </option>
        <option>
          <name>GenRtcIntOverflow</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcIncUnsigned</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcIntConversion</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcInclExplicit</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcIntShiftOverflow</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcInclUnsignedShiftOverflow</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcUnhandledCase</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcDivByZero</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcEnable</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcCheckPtrsNonInstrFunc</name>
          <state>1</state>
        </option>
      </data>
    </settings>
  </configuration>
  <configuration>
    <name>NODE</name>
    <toolchain>
      <name>ARM</name>
    </toolchain>
    <debug>1</debug>
    <settings>
      <name>RuntimeChecking</name>
      <archiveVersion>0</archiveVersion>
      <data>
        <version>2</version>
        <wantNonLocal>1</wantNonLocal>
        <debug>1</debug>
        <option>
          <name>GenRtcDebugHeap</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcEnableBoundsChecking</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcCheckPtrsNonInstrMem</name>
          <state>1</state>
        </option>
        <option>
          <name>GenRtcTrackPointerBounds</name>
          <state>1</state>
        </option>
        <option>
          <name>GenRtcCheckAccesses</name>
          <state>1</state>
        </option>
        <option>
          <name>GenRtcGenerateEntries</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcNrTrackedPointers</name>
          <state>1000</state>
        </option>
        <option>
          <name>GenRtcIntOverflow</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcIncUnsigned</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcIntConversion</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcInclExplicit</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcIntShiftOverflow</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcInclUnsignedShiftOverflow</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcUnhandledCase</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcDivByZero</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcEnable</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcCheckPtrsNonInstrFunc</name>
          <state>1</state>
        </option>
      </data>
    </settings>
  </configuration>
  <configuration>
    <name>NODE-ZC</name>
    <toolchain>
      <name>ARM</name>
    </toolchain>
    <debug>1</debug>
    <settings>
      <name>RuntimeChecking</name>
      <archiveVersion>0</archiveVersion>
      <data>
        <version>2</version>
        <wantNonLocal>1</wantNonLocal>
        <debug>1</debug>
        <option>
          <name>GenRtcDebugHeap</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcEnableBoundsChecking</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcCheckPtrsNonInstrMem</name>
          <state>1</state>
        </option>
        <option>
          <name>GenRtcTrackPointerBounds</name>
          <state>1</state>
        </option>
        <option>
          <name>GenRtcCheckAccesses</name>
          <state>1</state>
        </option>
        <option>
          <name>GenRtcGenerateEntries</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcNrTrackedPointers</name>
          <state>1000</state>
        </option>
        <option>
          <name>GenRtcIntOverflow</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcIncUnsigned</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcIntConversion</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcInclExplicit</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcIntShiftOverflow</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcInclUnsignedShiftOverflow</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcUnhandledCase</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcDivByZero</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcEnable</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcCheckPtrsNonInstrFunc</name>
          <state>1</state>
        </option>
      </data>
    </settings>
  </configuration>
  <configuration>
    <name>NODE-ZE</name>
    <toolchain>
      <name>ARM</name>
    </toolchain>
    <debug>1</debug>
    <settings>
      <name>RuntimeChecking</name>
      <archiveVersion>0</archiveVersion>
      <data>
        <version>2</version>
        <wantNonLocal>1</wantNonLocal>
        <debug>1</debug>
        <option>
          <name>GenRtcDebugHeap</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcEnableBoundsChecking</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcCheckPtrsNonInstrMem</name>
          <state>1</state>
        </option>
        <option>
          <name>GenRtcTrackPointerBounds</name>
          <state>1</state>
        </option>
        <option>
          <name>GenRtcCheckAccesses</name>
          <state>1</state>
        </option>
        <option>
          <name>GenRtcGenerateEntries</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcNrTrackedPointers</name>
          <state>1000</state>
        </option>
        <option>
          <name>GenRtcIntOverflow</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcIncUnsigned</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcIntConversion</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcInclExplicit</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcIntShiftOverflow</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcInclUnsignedShiftOverflow</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcUnhandledCase</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcDivByZero</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcEnable</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcCheckPtrsNonInstrFunc</name>
          <state>1</state>
        </option>
      </data>
    </settings>
  </configuration>
  <configuration>
    <name>NODE-ZR</name>
    <toolchain>
      <name>ARM</name>
    </toolchain>
    <debug>1</debug>
    <settings>
      <name>RuntimeChecking</name>
      <archiveVersion>0</archiveVersion>
      <data>
        <version>2</version>
        <wantNonLocal>1</wantNonLocal>
        <debug>1</debug>
        <option>
          <name>GenRtcDebugHeap</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcEnableBoundsChecking</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcCheckPtrsNonInstrMem</name>
          <state>1</state>
        </option>
        <option>
          <name>GenRtcTrackPointerBounds</name>
          <state>1</state>
        </option>
        <option>
          <name>GenRtcCheckAccesses</name>
          <state>1</state>
        </option>
        <option>
          <name>GenRtcGenerateEntries</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcNrTrackedPointers</name>
          <state>1000</state>
        </option>
        <option>
          <name>GenRtcIntOverflow</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcIncUnsigned</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcIntConversion</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcInclExplicit</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcIntShiftOverflow</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcInclUnsignedShiftOverflow</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcUnhandledCase</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcDivByZero</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcEnable</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcCheckPtrsNonInstrFunc</name>
          <state>1</state>
        </option>
      </data>
    </settings>
  </configuration>
  <group>
    <name>CMSIS</name>
    <file>
      <name>$PROJ_DIR$\..\..\..\Libraries\CMSIS\CM3\CoreSupport\core_cm3.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\system_stm32f2xx.c</name>
    </file>
  </group>
  <group>
    <name>Debug</name>
    <file>
      <name>$PROJ_DIR$\..\Debug\Debug.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\Debug\Debug.h</name>
    </file>
  </group>
  <group>
    <name>EWARM</name>
    <file>
      <name>$PROJ_DIR$\..\..\..\Libraries\CMSIS\CM3\DeviceSupport\ST\STM32F2xx\startup\iar\startup_stm32f2xx.s</name>
    </file>
  </group>
  <group>
    <name>Kernel</name>
    <file>
      <name>$PROJ_DIR$\..\Kernel\Hal_drivers.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\Kernel\Hal_drivers.h</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\Kernel\Hal_mcu.h</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\Kernel\Hal_timer.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\Kernel\Hal_timer.h</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\Kernel\hal_types.h</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\Kernel\Kernel.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\Kernel\Kernel.h</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\Kernel\Kernel_Memory.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\Kernel\Kernel_Memory.h</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\Kernel\Kernel_Tasks.h</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\Kernel\Kernel_Timers.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\Kernel\Kernel_Timers.h</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\Kernel\OnBoard.h</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\Kernel\ZComDef.h</name>
    </file>
  </group>
  <group>
    <name>SI4463</name>
    <file>
      <name>$PROJ_DIR$\..\SI4463\radio.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\SI4463\radio_comm.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\SI4463\radio_config.h</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\SI4463\radio_config_1st.h</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\SI4463\radio_config_2nd.h</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\SI4463\radio_hal.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\SI4463\radio_mcu.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\SI4463\si4463.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\SI4463\si4463_spi.c</name>
    </file>
  </group>
  <group>
    <name>STM32_EVAL</name>
    <file>
      <name>$PROJ_DIR$\..\..\..\Utilities\STM32_EVAL\STM322xG_EVAL\stm322xg_eval_fsmc_sram.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\Utilities\STM32_EVAL\STM322xG_EVAL\stm322xg_eval_ioe.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\Utilities\STM32_EVAL\STM322xG_EVAL\stm322xg_eval_lcd.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\Utilities\STM32_EVAL\stm32_eval.c</name>
    </file>
  </group>
  <group>
    <name>STM32F2xx_StdPeriph_Driver</name>
    <file>
      <name>$PROJ_DIR$\..\..\..\Libraries\STM32F2xx_StdPeriph_Driver\src\misc.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\Libraries\STM32F2xx_StdPeriph_Driver\src\stm32f2xx_adc.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\Libraries\STM32F2xx_StdPeriph_Driver\src\stm32f2xx_can.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\Libraries\STM32F2xx_StdPeriph_Driver\src\stm32f2xx_crc.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\Libraries\STM32F2xx_StdPeriph_Driver\src\stm32f2xx_cryp.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\Libraries\STM32F2xx_StdPeriph_Driver\src\stm32f2xx_cryp_aes.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\Libraries\STM32F2xx_StdPeriph_Driver\src\stm32f2xx_cryp_des.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\Libraries\STM32F2xx_StdPeriph_Driver\src\stm32f2xx_cryp_tdes.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\Libraries\STM32F2xx_StdPeriph_Driver\src\stm32f2xx_dac.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\Libraries\STM32F2xx_StdPeriph_Driver\src\stm32f2xx_dbgmcu.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\Libraries\STM32F2xx_StdPeriph_Driver\src\stm32f2xx_dcmi.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\Libraries\STM32F2xx_StdPeriph_Driver\src\stm32f2xx_dma.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\Libraries\STM32F2xx_StdPeriph_Driver\src\stm32f2xx_exti.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\Libraries\STM32F2xx_StdPeriph_Driver\src\stm32f2xx_flash.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\Libraries\STM32F2xx_StdPeriph_Driver\src\stm32f2xx_fsmc.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\Libraries\STM32F2xx_StdPeriph_Driver\src\stm32f2xx_gpio.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\Libraries\STM32F2xx_StdPeriph_Driver\src\stm32f2xx_hash.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\Libraries\STM32F2xx_StdPeriph_Driver\src\stm32f2xx_hash_md5.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\Libraries\STM32F2xx_StdPeriph_Driver\src\stm32f2xx_hash_sha1.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\Libraries\STM32F2xx_StdPeriph_Driver\src\stm32f2xx_i2c.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\Libraries\STM32F2xx_StdPeriph_Driver\src\stm32f2xx_iwdg.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\Libraries\STM32F2xx_StdPeriph_Driver\src\stm32f2xx_pwr.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\Libraries\STM32F2xx_StdPeriph_Driver\src\stm32f2xx_rcc.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\Libraries\STM32F2xx_StdPeriph_Driver\src\stm32f2xx_rng.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\Libraries\STM32F2xx_StdPeriph_Driver\src\stm32f2xx_rtc.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\Libraries\STM32F2xx_StdPeriph_Driver\src\stm32f2xx_sdio.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\Libraries\STM32F2xx_StdPeriph_Driver\src\stm32f2xx_spi.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\Libraries\STM32F2xx_StdPeriph_Driver\src\stm32f2xx_syscfg.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\Libraries\STM32F2xx_StdPeriph_Driver\src\stm32f2xx_tim.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\Libraries\STM32F2xx_StdPeriph_Driver\src\stm32f2xx_usart.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\Libraries\STM32F2xx_StdPeriph_Driver\src\stm32f2xx_wwdg.c</name>
    </file>
  </group>
  <group>
    <name>switch</name>
    <file>
      <name>$PROJ_DIR$\..\switch\SWITCH.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\switch\switch.h</name>
    </file>
  </group>
  <group>
    <name>User</name>
    <file>
      <name>$PROJ_DIR$\..\common.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\main.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\node.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\stm32f2xx_it.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\uart.c</name>
    </file>
  </group>
  <group>
    <name>ZB</name>
    <group>
      <name>aps</name>
      <file>
        <name>$PROJ_DIR$\..\ZB\aps\aps_bind.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\ZB\aps\aps_commands.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\ZB\aps\aps_dups.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\ZB\aps\aps_main.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\ZB\aps\aps_nwk_confirm.c</name>
      </file>
    </group>
    <group>
      <name>common</name>
      <file>
        <name>$PROJ_DIR$\..\ZB\common\zb_address.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\ZB\common\zb_bufpool.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\ZB\common\zb_bufpool_init.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\ZB\common\zb_debug.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\ZB\common\zb_ib.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\ZB\common\zb_init.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\ZB\common\zb_random.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\ZB\common\zb_scheduler.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\ZB\common\zb_scheduler_init.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\ZB\common\zb_time.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\ZB\common\zb_trace.c</name>
      </file>
    </group>
    <group>
      <name>mac</name>
      <file>
        <name>$PROJ_DIR$\..\ZB\mac\mac.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\ZB\mac\mac_associate.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\ZB\mac\mac_common.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\ZB\mac\mac_cr_associate.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\ZB\mac\mac_cr_coordinator.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\ZB\mac\mac_cr_data.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\ZB\mac\mac_data.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\ZB\mac\mac_disturber.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\ZB\mac\mac_fcs.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\ZB\mac\mac_routines.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\ZB\mac\mac_scan.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\ZB\mac\zb_cc25xx.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\ZB\mac\zb_cc25xx_common.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\ZB\mac\zb_ns3.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\ZB\mac\zb_si44xx.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\ZB\mac\zb_si44xx_common.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\ZB\mac\zb_uz2400.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\ZB\mac\zb_uz2410.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\ZB\mac\zb_uz2x_common.c</name>
      </file>
    </group>
    <group>
      <name>nwk</name>
      <file>
        <name>$PROJ_DIR$\..\ZB\nwk\nwk_address_assign.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\ZB\nwk\nwk_cr_formation.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\ZB\nwk\nwk_cr_join.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\ZB\nwk\nwk_cr_mesh_routing.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\ZB\nwk\nwk_cr_permit_join.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\ZB\nwk\nwk_cr_route_discovery.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\ZB\nwk\nwk_cr_tree_routing.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\ZB\nwk\nwk_discovery.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\ZB\nwk\nwk_formation.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\ZB\nwk\nwk_join.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\ZB\nwk\nwk_main.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\ZB\nwk\nwk_neighbor.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\ZB\nwk\nwk_nlme.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\ZB\nwk\nwk_panid_conflict.c</name>
      </file>
    </group>
    <group>
      <name>osif</name>
      <group>
        <name>8051</name>
        <file>
          <name>$PROJ_DIR$\..\ZB\osif\8051\zb_8051_dummy.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\ZB\osif\8051\zb_8051_nvram.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\ZB\osif\8051\zb_8051_serial.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\ZB\osif\8051\zb_8051_serial_init.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\ZB\osif\8051\zb_8051_spi.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\ZB\osif\8051\zb_8051_spi_init.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\ZB\osif\8051\zb_8051_xram.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\ZB\osif\8051\zb_mac_transport_8051_direct.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\ZB\osif\8051\zb_mac_transport_8051_ser.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\ZB\osif\8051\zb_mac_transport_8051_spi.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\ZB\osif\8051\zb_sysinit.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\ZB\osif\8051\zb_time_8051.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\ZB\osif\8051\zb_time_8051_init.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\ZB\osif\8051\zb_trace_8051.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\ZB\osif\8051\zb_uz2400_common.c</name>
        </file>
      </group>
    </group>
    <group>
      <name>secur</name>
      <file>
        <name>$PROJ_DIR$\..\ZB\secur\aps_secur.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\ZB\secur\apsme_secur.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\ZB\secur\mac_secur.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\ZB\secur\nwk_secur.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\ZB\secur\secur_ccm.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\ZB\secur\zb_TI_cc25xx_secur_ccm.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\ZB\secur\zdo_secur.c</name>
      </file>
    </group>
    <group>
      <name>tests</name>
      <group>
        <name>zdo_startup</name>
        <file>
          <name>$PROJ_DIR$\..\ZB\tests\zdo_startup\zdo_start_zc.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\ZB\tests\zdo_startup\zdo_start_ze.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\ZB\tests\zdo_startup\zdo_start_zr.c</name>
          <configuration>
            <name>NODE</name>
            <settings>
              <name>RuntimeChecking</name>
              <data>
                <version>2</version>
                <wantNonLocal>0</wantNonLocal>
                <debug>1</debug>
                <option>
                  <name>GenRtcTrackPointerBounds</name>
                  <state>1</state>
                </option>
                <option>
                  <name>GenRtcCheckAccesses</name>
                  <state>1</state>
                </option>
                <option>
                  <name>GenRtcGenerateEntries</name>
                  <state>0</state>
                </option>
                <option>
                  <name>GenRtcIntOverflow</name>
                  <state>0</state>
                </option>
                <option>
                  <name>GenRtcIncUnsigned</name>
                  <state>0</state>
                </option>
                <option>
                  <name>GenRtcIntConversion</name>
                  <state>0</state>
                </option>
                <option>
                  <name>GenRtcInclExplicit</name>
                  <state>0</state>
                </option>
                <option>
                  <name>GenRtcIntShiftOverflow</name>
                  <state>0</state>
                </option>
                <option>
                  <name>GenRtcInclUnsignedShiftOverflow</name>
                  <state>0</state>
                </option>
                <option>
                  <name>GenRtcUnhandledCase</name>
                  <state>0</state>
                </option>
                <option>
                  <name>GenRtcDivByZero</name>
                  <state>0</state>
                </option>
                <option>
                  <name>GenRtcCheckPtrsNonInstrFunc</name>
                  <state>1</state>
                </option>
              </data>
            </settings>
          </configuration>
          <configuration>
            <name>NODE-ZC</name>
            <settings>
              <name>RuntimeChecking</name>
              <data>
                <version>2</version>
                <wantNonLocal>1</wantNonLocal>
                <debug>1</debug>
                <option>
                  <name>GenRtcTrackPointerBounds</name>
                  <state>1</state>
                </option>
                <option>
                  <name>GenRtcCheckAccesses</name>
                  <state>1</state>
                </option>
                <option>
                  <name>GenRtcGenerateEntries</name>
                  <state>0</state>
                </option>
                <option>
                  <name>GenRtcIntOverflow</name>
                  <state>0</state>
                </option>
                <option>
                  <name>GenRtcIncUnsigned</name>
                  <state>0</state>
                </option>
                <option>
                  <name>GenRtcIntConversion</name>
                  <state>0</state>
                </option>
                <option>
                  <name>GenRtcInclExplicit</name>
                  <state>0</state>
                </option>
                <option>
                  <name>GenRtcIntShiftOverflow</name>
                  <state>0</state>
                </option>
                <option>
                  <name>GenRtcInclUnsignedShiftOverflow</name>
                  <state>0</state>
                </option>
                <option>
                  <name>GenRtcUnhandledCase</name>
                  <state>0</state>
                </option>
                <option>
                  <name>GenRtcDivByZero</name>
                  <state>0</state>
                </option>
                <option>
                  <name>GenRtcCheckPtrsNonInstrFunc</name>
                  <state>1</state>
                </option>
              </data>
            </settings>
          </configuration>
          <configuration>
            <name>NODE-ZE</name>
            <settings>
              <name>RuntimeChecking</name>
              <data>
                <version>2</version>
                <wantNonLocal>1</wantNonLocal>
                <debug>1</debug>
                <option>
                  <name>GenRtcTrackPointerBounds</name>
                  <state>1</state>
                </option>
                <option>
                  <name>GenRtcCheckAccesses</name>
                  <state>1</state>
                </option>
                <option>
                  <name>GenRtcGenerateEntries</name>
                  <state>0</state>
                </option>
                <option>
                  <name>GenRtcIntOverflow</name>
                  <state>0</state>
                </option>
                <option>
                  <name>GenRtcIncUnsigned</name>
                  <state>0</state>
                </option>
                <option>
                  <name>GenRtcIntConversion</name>
                  <state>0</state>
                </option>
                <option>
                  <name>GenRtcInclExplicit</name>
                  <state>0</state>
                </option>
                <option>
                  <name>GenRtcIntShiftOverflow</name>
                  <state>0</state>
                </option>
                <option>
                  <name>GenRtcInclUnsignedShiftOverflow</name>
                  <state>0</state>
                </option>
                <option>
                  <name>GenRtcUnhandledCase</name>
                  <state>0</state>
                </option>
                <option>
                  <name>GenRtcDivByZero</name>
                  <state>0</state>
                </option>
                <option>
                  <name>GenRtcCheckPtrsNonInstrFunc</name>
                  <state>1</state>
                </option>
              </data>
            </settings>
          </configuration>
          <configuration>
            <name>NODE-ZR</name>
            <settings>
              <name>RuntimeChecking</name>
              <data>
                <version>2</version>
                <wantNonLocal>1</wantNonLocal>
                <debug>1</debug>
                <option>
                  <name>GenRtcTrackPointerBounds</name>
                  <state>1</state>
                </option>
                <option>
                  <name>GenRtcCheckAccesses</name>
                  <state>1</state>
                </option>
                <option>
                  <name>GenRtcGenerateEntries</name>
                  <state>0</state>
                </option>
                <option>
                  <name>GenRtcIntOverflow</name>
                  <state>0</state>
                </option>
                <option>
                  <name>GenRtcIncUnsigned</name>
                  <state>0</state>
                </option>
                <option>
                  <name>GenRtcIntConversion</name>
                  <state>0</state>
                </option>
                <option>
                  <name>GenRtcInclExplicit</name>
                  <state>0</state>
                </option>
                <option>
                  <name>GenRtcIntShiftOverflow</name>
                  <state>0</state>
                </option>
                <option>
                  <name>GenRtcInclUnsignedShiftOverflow</name>
                  <state>0</state>
                </option>
                <option>
                  <name>GenRtcUnhandledCase</name>
                  <state>0</state>
                </option>
                <option>
                  <name>GenRtcDivByZero</name>
                  <state>0</state>
                </option>
                <option>
                  <name>GenRtcCheckPtrsNonInstrFunc</name>
                  <state>1</state>
                </option>
              </data>
            </settings>
          </configuration>
        </file>
      </group>
    </group>
    <group>
      <name>zdo</name>
      <file>
        <name>$PROJ_DIR$\..\ZB\zdo\af_descriptor.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\ZB\zdo\af_rx.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\ZB\zdo\test_profile.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\ZB\zdo\zdo_app.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\ZB\zdo\zdo_bind_manage.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\ZB\zdo\zdo_channel_manager.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\ZB\zdo\zdo_common.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\ZB\zdo\zdo_disc_cli.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\ZB\zdo\zdo_disc_srv.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\ZB\zdo\zdo_nwk_manage_cli.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\ZB\zdo\zdo_nwk_manage_srv.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\ZB\zdo\zdo_rx.c</name>
      </file>
    </group>
  </group>
</project>


