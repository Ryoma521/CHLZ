# IAR project chl_prj.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: STM32L151x8 ST STM32L151x8
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: ZB_PLATFORM_8051_SIM; ZB_CC25XX; ZB_IAR; ZB_SECURITY; xZB_ED_ROLE; xZB_TRACE_LEVEL=2; xZB_TRAFFIC_DUMP_ON
  ICCARM.CCIncludePath2: include; osif\include
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: chl_prj.srec
  ILINK.IlinkOutputFile: c.out
  ILINK.IlinkIcfFile: $TOOLKIT_DIR$\config\linker\ST\stm32l151x8.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.OGChipSelectEditMenu: default None
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  OBJCOPY.OOCOutputFile: c.srec
configuration CHL_ZC_DEBUG (ARM, debug)
  as the first configuration, except:
  ICCARM.CCDefines: xZB_PLATFORM_8051_SIM; ZB_SI44XX; xZB_CC25XX; ZB_IAR; ZB_SECURITY; xZB_ED_ROLE; xZB_TRACE_LEVEL=2; xZB_TRAFFIC_DUMP_ON
  ICCARM.CCIncludePath2: ZBOSS_v1.0_src\include; ZBOSS_v1.0_src\osif\include
configuration CHL_ZR_DEBUG (ARM, debug)
  as the first configuration, except:
configuration CHL_ZE_DEBUG (ARM, debug)
  as the first configuration, except:
  group aps
    ZBOSS_v1.0_src/aps/: aps_bind.c aps_commands.c aps_dups.c aps_main.c aps_nwk_confirm.c
  group common
    ZBOSS_v1.0_src/common/: zb_address.c zb_bufpool.c zb_bufpool_init.c zb_debug.c zb_ib.c zb_init.c zb_random.c zb_scheduler.c zb_scheduler_init.c zb_time.c zb_trace.c
  group mac
    ZBOSS_v1.0_src/mac/: mac.c mac_associate.c mac_common.c mac_cr_associate.c mac_cr_coordinator.c mac_cr_data.c mac_data.c mac_disturber.c mac_fcs.c mac_routines.c mac_scan.c zb_cc25xx.c zb_cc25xx_common.c zb_ns3.c zb_si44xx.c zb_uz2400.c zb_uz2410.c zb_uz2x_common.c
  group nwk
    ZBOSS_v1.0_src/nwk/: nwk_address_assign.c nwk_cr_formation.c nwk_cr_join.c nwk_cr_mesh_routing.c nwk_cr_permit_join.c nwk_cr_route_discovery.c nwk_cr_tree_routing.c nwk_discovery.c nwk_formation.c nwk_join.c nwk_main.c nwk_neighbor.c nwk_nlme.c nwk_panid_conflict.c
  group secur
    ZBOSS_v1.0_src/secur/: aps_secur.c apsme_secur.c mac_secur.c nwk_secur.c secur_ccm.c zb_TI_cc25xx_secur_ccm.c zdo_secur.c
  group tests/zdo_startup
    ZBOSS_v1.0_src/tests/zdo_startup/: zdo_start_zc.c zdo_start_ze.c zdo_start_zr.c
  group zdo
    ZBOSS_v1.0_src/zdo/: af_descriptor.c af_rx.c test_profile.c zdo_app.c zdo_bind_manage.c zdo_channel_manager.c zdo_common.c zdo_disc_cli.c zdo_disc_srv.c zdo_nwk_manage_cli.c zdo_nwk_manage_srv.c zdo_rx.c
